options:
  parameters:
    author: Daniel Fernandez, Andres Suarez
    copyright: UIS
    generate_options: qt_gui
    id: ModulacionPM
    output_language: python
    title: ModulacionPM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud_Mensaje
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia_Portadora
    start: '50000000'
    step: '1000000'
    stop: '2000000000'
    value: '50000000'
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia_mensaje
    start: '1000'
    step: '100'
    stop: '200000'
    value: '1000'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente kp
    start: '0'
    step: '0.000001'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: EnvolventecomplejaPML1AG3_0
  id: EnvolventecomplejaPML1AG3
  parameters:
    Ac: Ac
    kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventecomplejaPML1AG3_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventecomplejaPML1AG3_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventecomplejaPML1AG3_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', EnvolventecomplejaPML1AG3_0, '0']

metadata:
  file_format: 1
