options:
  parameters:
    author: Daniel_Fernandez_Andres_Suarez
    copyright: Daniel_Fernandez_Andres_Suarez
    generate_options: qt_gui
    id: Modulador_PWM
    output_language: python
    title: Modulador_PWM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud_diente_de_sierra
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '2'
  states: {}
- name: Ar
  id: variable_qtgui_range
  parameters:
    label: Amplitud_constante
    start: '-2'
    step: '0.1'
    stop: '2'
    value: '0'
  states: {}
- name: DC
  id: variable_qtgui_range
  parameters:
    label: Nivel_de_diente_de_sierra
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia_Portadora
    start: '50000000'
    step: '1000000'
    stop: '1000000000'
    value: '50000000'
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia_mensaje
    start: '100'
    step: '10'
    stop: '1000'
    value: '200'
  states: {}
- name: Fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia_diente_de_sierra
    start: '100'
    step: '10'
    stop: '10000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ModulosEfren_Compara_0
  id: ModulosEfren_Compara
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Ar
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: Fs
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModulosEfren_Compara_0, '0', blocks_float_to_complex_0, '0']
- [ModulosEfren_Compara_0, '0', qtgui_freq_sink_x_0, '0']
- [ModulosEfren_Compara_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0_0, '0', ModulosEfren_Compara_0, '1']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle_0, '0', ModulosEfren_Compara_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
