options:
  parameters:
    author: Daniel Fernandez
    generate_options: qt_gui
    id: PotenciaD
    output_language: python
    title: PotenciaD
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '25'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}

connections:
- [analog_sig_source_x_0, '0', CalculoPotenciaComunicaciones_0, '0']

metadata:
  file_format: 1
